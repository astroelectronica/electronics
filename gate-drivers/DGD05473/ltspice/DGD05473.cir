.title KiCad schematic
.include "C:/AE/DGD05473/ATLI_860080772001_10uF.lib"
.include "C:/AE/DGD05473/DGD05473.spice.txt"
.include "C:/AE/DGD05473/DMN6017SK3.spice.txt"
.include "C:/AE/DGD05473/US1A.spice.txt"
.include "C:/AE/DGD05473/c2012np02a102j060aa_p.mod"
.include "C:/AE/DGD05473/c2012x7r2a104k125ae_p.mod"
.include "C:/AE/DGD05473/c2012x7s2a105k125ae_p.mod"
.include "C:/AE/DGD05473/caa573x7s2a476m640lh_p.mod"
XU11 /G3 /OUT_L C2012NP02A102J060AA_p
XQ4 /OUT_L /G4 /CSB DMN6017SK3
R13 /CSB 0 {RCSB}
XU12 /G4 /CSB C2012NP02A102J060AA_p
R11 /LO_Q4 /RD4 {RRG4}
R12 /LO_Q4 /G4 {RG4}
D4 /RD4 /G4 DI_US1A
D3 /RD3 /G3 DI_US1A
XU3 /G1 /OUT_H C2012NP02A102J060AA_p
XU4 /G2 /CSA C2012NP02A102J060AA_p
R4 /LO_Q2 /G2 {RG2}
R10 /HO_Q3 /G3 {RG3}
R9 /HO_Q3 /RD3 {RRG3}
XU10 /VB_L /OUT_L C2012X7S2A105K125AE_p
R1 /HO_Q1 /G1 {RG1}
D2 /RD2 /G2 DI_US1A
D1 /RD1 /G1 DI_US1A
XU2 /VB_H /OUT_H C2012X7S2A105K125AE_p
R3 /LO_Q2 /RD2 {RRG2}
XQ1 VBUS /G1 /OUT_H DMN6017SK3
R5 /CSA 0 {RCSA}
XQ2 /OUT_H /G2 /CSA DMN6017SK3
XU7 VBUS 0 C2012X7S2A105K125AE_p
XQ3 VBUS /G3 /OUT_L DMN6017SK3
L1 /OUT_L Net-_C1-Pad2_ {LLOAD}
C1 /OUT_H Net-_C1-Pad2_ {CLOAD}
XU8 VBUS 0 ATLI_860080772001_10uF
XU13 VBUS 0 C2012X7S2A105K125AE_p
XU16 VCC 0 C2012X7R2A104K125AE_p
XU9 VCC unconnected-_U9-NC-Pad2_ /VB_L /HO_Q3 /OUT_L /EN_Q4 /HIN_Q3 /LIN_Q4 0 /LO_Q4 dgd05473
R8 VCC /EN_Q4 {RPU}
V3 /HIN_Q3 0 DC PULSE(0 {VPUL} {DELAY_Q3} {TR} {TF} {DUTY_Q3} {CYCLE}
V4 /LIN_Q4 0 DC PULSE(0 {VPUL} {DELAY_Q4} {TR} {TF} {DUTY_Q4} {CYCLE}
XU15 VCC 0 CAA573X7S2A476M640LH_p
V5 VCC 0 DC {VCC}
V6 VBUS 0 DC {VBUS}
V1 /HIN_Q1 0 DC PULSE(0 {VPUL} {DELAY_Q1} {TR} {TF} {DUTY_Q1} {CYCLE}
V2 /LIN_Q2 0 DC PULSE(0 {VPUL} {DELAY_Q2} {TR} {TF} {DUTY_Q2} {CYCLE}
XU6 VCC 0 C2012X7R2A104K125AE_p
R6 VCC /EN_H {RPU}
XU1 VCC unconnected-_U1-NC-Pad2_ /VB_H /HO_Q1 /OUT_H /EN_H /HIN_Q1 /LIN_Q2 0 /LO_Q2 dgd05473
R2 /HO_Q1 /RD1 {RRG1}
XU5 VCC 0 CAA573X7S2A476M640LH_p
.end
